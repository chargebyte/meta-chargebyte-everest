# just set our default timezone to Germany
DEFAULT_TIMEZONE = "Europe/Berlin"
