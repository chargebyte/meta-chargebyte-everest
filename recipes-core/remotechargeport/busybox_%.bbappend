FILESEXTRAPATHS:prepend := "${THISDIR}/busybox:"

SRC_URI += " \
    file://enable-ftpd-without-auth.cfg \
"
