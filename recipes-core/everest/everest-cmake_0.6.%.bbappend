FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += " \
    file://0001-Restrict-git-describe-tag-search-to-standard-pattern.patch \
"

SRCREV = "e2a532602deaf0abdabbb340ee6fd5189573e169"
