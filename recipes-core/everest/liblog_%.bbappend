FILESEXTRAPATHS:prepend := "${THISDIR}/liblog:"

SRC_URI += " \
    file://0001-Pretty-print-none-info-messages.patch \
"
