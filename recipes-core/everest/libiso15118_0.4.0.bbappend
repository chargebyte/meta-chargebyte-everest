FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += " \
    file://0001-Add-PRE_CHARGE_STARTED-signal.patch \
"
