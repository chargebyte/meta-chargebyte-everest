EXTRA_OECMAKE += " \
	-DBUILD_SHARED_LIBS=ON \
"
