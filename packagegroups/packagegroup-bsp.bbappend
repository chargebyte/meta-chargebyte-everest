#
# Notes:
# - tar is required for special options in update shell scripts
#
RDEPENDS:${PN} += " \
    tar \
"
